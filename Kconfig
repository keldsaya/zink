## Kconfig
```kconfig
menu General Setup

config SAMPLE
  bool "Sample feature"
  default y
  help
    Config stub for testing

endmenu
```
